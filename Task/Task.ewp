# IAR project Task.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: C:\stm32_proj\Libraries\STM32F429I-Discovery; C:\stm32_proj\Libraries\CMSIS\Inc; C:\stm32_proj\Libraries\STM32F4xx_HAL_Driver\Inc; C:\stm32_proj\Libraries\CMSIS\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.2\arm\inc\c
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Task.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f429xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/CMSIS
    ../Libraries/CMSIS/Src/: system_stm32f4xx.c
  group Drivers/STM32F429I-DISCOVERY
    ../Libraries/STM32F429I-Discovery/: stm32f429i_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group EWARM
    ../Libraries/EWARM/: startup_stm32f429xx.s
  group user
    ./: main.c
    ../Libraries/CMSIS/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
